FILESEXTRAPATHS:prepend := "${THISDIR}/wpewebkit:"

SRC_URI += "file://0001-WTF-Guard-invalid-enum-constants-with-Clang-20.patch"
