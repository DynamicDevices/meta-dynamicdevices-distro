# Hardware-specific ALSA defaults belong to the BSP's alsa-state append.
# Keep the package machine-specific without replacing /etc/asound.conf here.
PACKAGE_ARCH = "${MACHINE_ARCH}"
