# MDIO/PHY bring-up (DT510, KSZ9896) — meta-networking: phytool, mdio-tools
CORE_IMAGE_BASE_INSTALL:append:imx8mm-jaguar-dt510 = " phytool mdio-tools"
